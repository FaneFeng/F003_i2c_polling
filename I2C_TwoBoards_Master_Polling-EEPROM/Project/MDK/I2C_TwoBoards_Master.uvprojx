# Keil uVision project I2C_TwoBoards_Master.uvprojx, settings and files
target I2C_TwoBoards_Master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F003F6 Geehy
  pack: Geehy.APM32F00x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_TwoBoards_Master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Include;..\..\..\..\..\..\Board;..\..\..\..\..\..\Library\APM32F00x_StdPeriphDriver\inc;..\..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\..\Library\Device\Geehy\APM32F00x\Include;..\MDK
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../../Library/Device/Geehy/APM32F00x/Source/: system_apm32f00x.c
    ../../../../../../Library/Device/Geehy/APM32F00x/Source/ARM/: startup_apm32f0xx.s
  group StdPeriphDriver
    ../../../../../../Library/APM32F00x_StdPeriphDriver/src/: apm32f00x_rcm.c apm32f00x_misc.c apm32f00x_i2c.c apm32f00x_gpio.c apm32f00x_eint.c
  group Board
    ../../../../../../Board/: Board.c
  group Application
    ../../Source/: main.c apm32f00x_int.c
  group EEPROM
    ./: eeprom.c eeprom.h
